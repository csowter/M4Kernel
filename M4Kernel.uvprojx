# Keil uVision project M4Kernel.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: M4Kernel
  group Source Group 1
    ./Source/: M4Exceptions.s Startup.s VectorTable.s stm32f407.inc CortexM4.inc STM32F407Exceptions.s SysTick.s Kernel.s
